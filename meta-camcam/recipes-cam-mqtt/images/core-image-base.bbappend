IMAGE_INSTALL_append = " cam-mqtt " 
